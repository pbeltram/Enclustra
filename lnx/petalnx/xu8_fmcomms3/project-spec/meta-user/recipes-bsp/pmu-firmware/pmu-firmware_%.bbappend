#Add debug for PMUFW
#XSCTH_BUILD_DEBUG = "1"

