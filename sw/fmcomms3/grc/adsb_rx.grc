options:
  parameters:
    author: Matt Hostetter
    category: Custom
    generate_options: qt_gui
    id: adsb_rx
    output_language: python
    title: ADS-B Receiver
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: '1090000000'
  states: {}
- name: fs
  id: variable
  parameters:
    value: '6000000'
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Gain (dB)
    type: real
    value: '100'
  states: {}
- name: threshold
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: Detection Threshold
    type: real
    value: '0.010'
  states: {}
- name: adsb_decoder_0
  id: adsb_decoder
  parameters:
    error_corr: '"None"'
    msg_filter: '"Extended Squitter Only"'
    print_level: '"Brief"'
  states: {}
- name: adsb_demod_0
  id: adsb_demod
  parameters:
    fs: fs
  states: {}
- name: adsb_framer_1
  id: adsb_framer
  parameters:
    fs: fs
    threshold: threshold
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: threshold
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '0x8000'
    frequency: fc
    gain2: '''slow_attack'''
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'False'
    rx2_en: 'True'
    samplerate: fs
    uri: uri
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: ''
    label2: ''
    legend: 'False'
    marker1: '0'
    nconnections: '2'
    size: int(fs*150e-6)
    srate: int(fs)
    tr_delay: '1.25e-6'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
    ymin: '0'
  states: {}
- name: uri
  id: parameter
  parameters:
    label: URI
    value: '''ip:xu8'''
  states: {}

connections:
- [adsb_demod_0, '0', qtgui_time_sink_x_0, '0']
- [adsb_demod_0, demodulated, adsb_decoder_0, demodulated]
- [adsb_framer_1, '0', adsb_demod_0, '0']
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_squared_0, '0', adsb_framer_1, '0']
- [iio_fmcomms2_source_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
