options:
  parameters:
    category: Custom
    description: 'Interactive monitor of a single C0 channel with analysis performed by Wireshark (command to run wireshark: sudo wireshark -k -f udp -Y gsmtap -i lo)'
    generate_options: qt_gui
    id: grgsm_livemon_uhd
    output_language: python
    title: Gr GSM Livemon
  states: {}

blocks:
- name: fc_slider
  id: variable_qtgui_range
  parameters:
    label: Frequency
    min_len: '100'
    orient: Qt.Horizontal
    start: 800e6
    step: 2e5
    stop: 1990e6
    value: fc
  states: {}
- name: gain_slider
  id: variable_qtgui_range
  parameters:
    label: Gain
    min_len: '100'
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '50'
    value: gain
    widget: counter
  states: {}
- name: blocks_socket_pdu_1
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '1500'
    port: '4729'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: collector
  id: parameter
  parameters:
    label: IP or DNS name of collector point
    value: '''localhost'''
  states: {}
- name: collectorport
  id: parameter
  parameters:
    label: UDP port number of collector
    value: '''4729'''
  states: {}
- name: fc
  id: parameter
  parameters:
    label: fc
    type: eng_float
    value: 936.6e6
  states: {}
- name: gain
  id: parameter
  parameters:
    label: gain
    type: eng_float
    value: '30'
  states: {}
- name: gsm_bcch_ccch_demapper_0
  id: gsm_bcch_ccch_demapper
  parameters:
    timeslot_nr: '0'
  states: {}
- name: gsm_clock_offset_control_0
  id: gsm_clock_offset_control
  parameters:
    fc: fc_slider-shiftoff
    osr: osr
    samp_rate: samp_rate
  states: {}
- name: gsm_control_channels_decoder_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_1
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_decryption_0
  id: gsm_decryption
  parameters:
    a5_version: '1'
    k_c: '[]'
  states: {}
- name: gsm_input_0
  id: gsm_input
  parameters:
    fc: fc_slider-shiftoff
    ppm: ppm-int(ppm)
    samp_rate_in: samp_rate
  states: {}
- name: gsm_message_printer_0
  id: gsm_message_printer
  parameters:
    prepend_fnr: 'True'
    prepend_frame_count: 'True'
    prepend_string: '"MSG1"'
    print_gsmtap_header: 'True'
  states: {}
- name: gsm_message_printer_1
  id: gsm_message_printer
  parameters:
    prepend_fnr: 'True'
    prepend_frame_count: 'True'
    prepend_string: '"MSG0"'
    print_gsmtap_header: 'True'
  states: {}
- name: gsm_receiver_0
  id: gsm_receiver
  parameters:
    cell_allocation: '[int(arfcn.downlink2arfcn(int(fc)))]'
    osr: osr
  states: {}
- name: gsm_sdcch8_demapper_0
  id: gsm_sdcch8_demapper
  parameters:
    timeslot_nr: '1'
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    auto_filter: 'True'
    bandwidth: int(250000+abs(shiftoff))
    bbdc: 'True'
    buffer_size: '0x8000'
    frequency: int(fc_slider-shiftoff)
    gain1: '''manual'''
    manual_gain1: gain
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: int(samp_rate)
    uri: uri
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from grgsm import arfcn
  states: {}
- name: osr
  id: parameter
  parameters:
    label: OverSampling Ratio
    type: intx
    value: '4'
  states: {}
- name: ppm
  id: parameter
  parameters:
    label: ppm
    short_id: p
    type: eng_float
    value: '0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc_slider
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    short_id: s
    type: eng_float
    value: '2000000.052982'
  states: {}
- name: shiftoff
  id: parameter
  parameters:
    label: Frequency Shiftoff
    short_id: o
    type: eng_float
    value: '0'
  states: {}
- name: uri
  id: parameter
  parameters:
    label: URI
    value: '''ip:xu8'''
  states: {}

connections:
- [gsm_bcch_ccch_demapper_0, bursts, gsm_control_channels_decoder_0, bursts]
- [gsm_clock_offset_control_0, ctrl, gsm_input_0, ctrl_in]
- [gsm_control_channels_decoder_0, msgs, blocks_socket_pdu_1, pdus]
- [gsm_control_channels_decoder_0, msgs, gsm_message_printer_1, msgs]
- [gsm_control_channels_decoder_1, msgs, blocks_socket_pdu_1, pdus]
- [gsm_control_channels_decoder_1, msgs, gsm_message_printer_0, msgs]
- [gsm_decryption_0, bursts, gsm_control_channels_decoder_1, bursts]
- [gsm_input_0, '0', gsm_receiver_0, '0']
- [gsm_receiver_0, C0, gsm_bcch_ccch_demapper_0, bursts]
- [gsm_receiver_0, C0, gsm_sdcch8_demapper_0, bursts]
- [gsm_receiver_0, measurements, gsm_clock_offset_control_0, measurements]
- [gsm_sdcch8_demapper_0, bursts, gsm_decryption_0, bursts]
- [iio_fmcomms2_source_0, '0', gsm_input_0, '0']
- [iio_fmcomms2_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
