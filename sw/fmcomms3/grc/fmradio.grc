options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: fmradio
    output_language: python
    realtime_scheduling: '1'
    run_options: run
  states: {}

blocks:
- name: sample_rate
  id: variable
  parameters:
    value: '2200000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '8'
    quad_rate: '384000'
  states: {}
- name: audio_device
  id: parameter
  parameters:
    label: Audio device
    value: '''default'''
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: audio_device
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: Decimation
    type: intx
    value: '1'
  states: {}
- name: fm_station
  id: parameter
  parameters:
    label: FM station
    type: intx
    value: '90613000'
  states: {}
- name: hostname
  id: parameter
  parameters:
    label: Hostname
    type: str
    value: localhost
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '0x20000'
    frequency: fm_station
    gain2: '''slow_attack'''
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'False'
    rx2_en: 'True'
    samplerate: sample_rate
    uri: uri
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '44100'
    decim: int(sample_rate / (384000 * decimation))
    gain: '1'
    samp_rate: sample_rate / decimation
    type: fir_filter_ccf
    width: '44100'
    win: firdes.WIN_HAMMING
  states: {}
- name: uri
  id: parameter
  parameters:
    label: URI
    value: '''ip:xu8'''
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '1', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', low_pass_filter_0, '0']
- [iio_fmcomms2_source_0, '0', blocks_complex_to_float_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
